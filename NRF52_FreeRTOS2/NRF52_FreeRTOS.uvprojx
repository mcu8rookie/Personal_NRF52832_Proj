# Keil uVision project NRF52_FreeRTOS.uvprojx, settings and files
target NRF52_FreeRTOS (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.59.0
  cpu: IROM(0x00000000,0x00080000) IRAM(0x20000000,0x00010000) IRAM2(0x00800000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: NRF52_GPIO
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=2
  c define: NRF52 NRF52832_XXAA
  c include: .\UsrCode;..\nRF5_SDK_17.1.0_ddde560\modules\nrfx\mdk;..\nRF5_SDK_17.1.0_ddde560\modules\nrfx;..\nRF5_SDK_17.1.0_ddde560\modules\nrfx\hal;..\nRF5_SDK_17.1.0_ddde560\components\libraries\delay;..\nRF5_SDK_17.1.0_ddde560\modules\nrfx\drivers;..\nRF5_SDK_17.1.0_ddde560\modules\nrfx\drivers\include;..\nRF5_SDK_17.1.0_ddde560\config\nrf52832\config;..\nRF5_SDK_17.1.0_ddde560\components\libraries\util;..\nRF5_SDK_17.1.0_ddde560\components\drivers_nrf\nrf_soc_nosd;..\nRF5_SDK_17.1.0_ddde560\components\libraries\uart;..\nRF5_SDK_17.1.0_ddde560\components\libraries\log;..\nRF5_SDK_17.1.0_ddde560\components\libraries\experimental_section_vars;..\nRF5_SDK_17.1.0_ddde560\components\libraries\log\src;..\nRF5_SDK_17.1.0_ddde560\components\libraries\strerror;..\nRF5_SDK_17.1.0_ddde560\components\libraries\fifo;..\nRF5_SDK_17.1.0_ddde560\integration\nrfx\legacy;..\nRF5_SDK_17.1.0_ddde560\components\libraries\log;..\nRF5_SDK_17.1.0_ddde560\modules\nrfx\drivers\src\prs;..\nRF5_SDK_17.1.0_ddde560\integration\nrfx;.\UsrCode\FreeRTOS_Kernel_V20240601_LTS\include;.\UsrCode\FreeRTOS_Kernel_V20240601_LTS\portable\RVDS\ARM_CM4F;.\UsrCode\FreeRTOS_Kernel_V20240601_LTS
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x800000 size 0x10000
  group MCU_Lib
    ../nRF5_SDK_17.1.0_ddde560/components/libraries/uart/: app_uart_fifo.c retarget.c
    ../nRF5_SDK_17.1.0_ddde560/components/libraries/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c
    ../nRF5_SDK_17.1.0_ddde560/modules/nrfx/drivers/src/: nrfx_uart.c nrfx_uarte.c nrfx_timer.c nrfx_twi.c
    ../nRF5_SDK_17.1.0_ddde560/components/libraries/fifo/: app_fifo.c
    ../nRF5_SDK_17.1.0_ddde560/integration/nrfx/legacy/: nrf_drv_uart.c nrf_drv_twi.c
    ../nRF5_SDK_17.1.0_ddde560/modules/nrfx/drivers/src/prs/: nrfx_prs.c
  group FreeRTOS
    ./UsrCode/FreeRTOS_Kernel_V20240601_LTS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./UsrCode/FreeRTOS_Kernel_V20240601_LTS/portable/MemMang/: heap_4.c
    ./UsrCode/FreeRTOS_Kernel_V20240601_LTS/portable/RVDS/ARM_CM4F/: port.c
  group Usr_Code
    ./UsrCode/: Usr_Main.c Usr_Code.c Usr_GPIO.c Usr_Uart.c Usr_Mcu.c Usr_Board.c Usr_Timer.c Usr_I2C.c Usr_Task.c Usr_I2C_Sensor.c
software components: CMSIS:CORE 5.3.0, Device:Startup 8.17.0
