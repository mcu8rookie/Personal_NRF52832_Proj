# Keil uVision project NRF52_GPIO.uvprojx, settings and files
target Usr_GPIO (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.59.0
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x00800000,0x00010000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: NRF52_GPIO
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=2
  c define: NRF52
  c include: .\UsrCode;..\nRF5_SDK_17.1.0_ddde560\modules\nrfx\mdk;..\nRF5_SDK_17.1.0_ddde560\modules\nrfx;..\nRF5_SDK_17.1.0_ddde560\modules\nrfx\hal;..\nRF5_SDK_17.1.0_ddde560\modules\nrfx\templates;..\nRF5_SDK_17.1.0_ddde560\modules\nrfx\templates\nRF52832;..\nRF5_SDK_17.1.0_ddde560\components\libraries\delay
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x800000 size 0x10000
  group Usr_Code
    ./UsrCode/: Usr_Main.c Usr_Code.c Usr_GPIO.c Usr_Mcu.c Usr_Board.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.5.0
